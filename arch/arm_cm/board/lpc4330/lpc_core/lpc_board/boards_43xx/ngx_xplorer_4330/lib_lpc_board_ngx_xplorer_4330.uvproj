# Keil uVision project lib_lpc_board_ngx_xplorer_4330.uvproj, settings and files
target ngx_xplorer_4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lib_lpc_board_ngx_xplorer_4330 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\lpc_chip\chip_18xx_43xx;..\..\..\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\lpc_chip\chip_common;..\..\board_common;.
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: board.c board_sysinit.c
    ../../board_common/: uda1380.c mem_tests.c lpc_phy_smsc87x0.c
