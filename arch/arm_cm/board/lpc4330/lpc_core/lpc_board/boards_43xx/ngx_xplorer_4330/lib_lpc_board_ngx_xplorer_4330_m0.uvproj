# Keil uVision project lib_lpc_board_ngx_xplorer_4330_m0.uvproj, settings and files
target ngx_xplorer_4330_m0 (ARM-ADS)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lib_lpc_board_ngx_xplorer_4330_m0 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\lpc_chip\chip_18xx_43xx;..\..\..\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\lpc_chip\chip_common;..\..\board_common;.
  group src
    ./: board.c board_sysinit.c
  group common
    ../../board_common/: mem_tests.c uda1380.c lpc_phy_smsc87x0.c
