# IAR project lib_lpc_board_ngx_xplorer_4330.ewp, settings and files
configuration ngx_xplorer_4330 (ARM)
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../lpc_chip/chip_18xx_43xx; ../../../lpc_chip/chip_18xx_43xx/config_43xx; ../../../lpc_chip/chip_common; ../../../../CMSIS/CMSIS/Include; ../../board_common; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  ILINK.IlinkOutputFile: lib_lpc_board_ngx_xplorer_4330.out
  group src
    ./: board.c board_sysinit.c
    ../../board_common/: lpc_phy_smsc87x0.c mem_tests.c uda1380.c
